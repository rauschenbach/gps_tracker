# IAR project gps_tracker_rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; SYSCLK_FREQ_48MHz; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: ..\; ..\..\STM32F10x-Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\STM32F10x-Library\STM32F10x_StdPeriph_Driver\inc; ..\..\STM32F10x-Library\CMSIS\Include; ..\periph; ..\sdcard; ..\log; ..\driver; ..\fatfs; ..\utils\; ..\stdio\; ..\modules\; ..\CMSIS\Include\; ..\..\oslib\FreeRTOS\Source\include; ..\..\oslib\FreeRTOS\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\
  OBJCOPY.OOCOutputFile: gps_tracker_rtos.srec
  ILINK.IlinkOutputFile: gps_tracker_rtos.out
  ILINK.IlinkIcfFile: gps_tracker_rtos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c stm32f10x_it.c
  group CMSIS
    ../../STM32F10x-Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../../STM32F10x-Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group driver
    ../driver/: lsm303.c lsm303dlhc_drv.c sim900.c
  group fatfs
    ../fatfs/: diskio.c ff.c
  group log
    ../log/: log.c minIni.c
  group oslib
    ../../oslib/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../oslib/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../oslib/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group periph
    ../periph/: board.c gps.c gsm.c led.c rtc.c usart.c
  group sdcard
    ../sdcard/: sdio_drv.c
  group StdPeriph_Driver
    ../../STM32F10x-Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_usart.c
  group utils
    ../utils/: circbuf.c utils.c
